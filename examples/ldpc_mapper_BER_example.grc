options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: SNR
  id: variable_qtgui_entry
  parameters:
    label: SNR
    type: real
    value: '10'
  states: {}
- name: base_ldpc_block_len
  id: variable
  parameters:
    value: '2304'
  states: {}
- name: cfo
  id: variable_qtgui_range
  parameters:
    label: Freq Offset
    orient: Qt.Horizontal
    start: '-1e-1'
    step: '1e-3'
    stop: '1e-1'
    value: '0'
  states: {}
- name: codeword_len
  id: variable
  parameters:
    value: (z_factor / 96.0) * base_ldpc_block_len
  states: {}
- name: dataword_len
  id: variable
  parameters:
    value: codeword_len * rate
  states: {}
- name: pream
  id: variable
  parameters:
    value: (mapper.preamble_generator(preamble_len,511,1033)).get_preamble()
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rate
  id: variable
  parameters:
    value: 2.0/3.0
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: sro
  id: variable_qtgui_range
  parameters:
    label: Sample Rate Offset
    orient: Qt.Horizontal
    start: '-1e-1'
    step: '1e-3'
    stop: '1e-1'
    value: '0'
  states: {}
- name: z_factor
  id: variable
  parameters:
    value: '24'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pdu_length
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(dataword_len)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(codeword_len)
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1.0+sro
    freq_offset: cfo
    noise_voltage: (10**(-SNR/10.0))*np.sqrt(samp_per_sym)
    seed: '0'
    taps: '[1]'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '0.000001'
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '1e-8'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from cmath import exp, pi; from random import randint; import numpy as np;
  states: {}
- name: mapper_mapper_0
  id: mapper_mapper
  parameters:
    modtype: mapper.QPSK
    symbol_values: '[0,1,3,2]'
  states: {}
- name: mapper_prbs_sink_b_0
  id: mapper_prbs_sink_b
  parameters:
    reset_len: int(dataword_len)
    which_mode: '"PRBS31"'
  states: {}
- name: mapper_prbs_source_b_0
  id: mapper_prbs_source_b
  parameters:
    reset_len: int(dataword_len)
    which_mode: '"PRBS31"'
  states: {}
- name: mapper_preamble_insert_bb_0
  id: mapper_preamble_insert_bb
  parameters:
    preamble: pream
    width: int(codeword_len) + preamble_len
  states: {}
- name: mapper_preamble_sync_demapper_0
  id: mapper_preamble_sync_demapper
  parameters:
    acquire_bit_thresh: '1'
    loose_bit_thresh: '3'
    modtype: mapper.QPSK
    passthrough: 'False'
    preamble: pream
    symbol_map: '[0,1,3,2]'
    width: int(codeword_len) + preamble_len
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: QT GUI Plot
    size: 840-84
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: 'int(codeword_len) '
    nrows: '100'
    samp_rate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: samp_per_sym
    ntaps: '11'
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: samp_per_sym*0+1
    ntaps: '11'
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_ccf
  states: {}
- name: wimaxldpc_ldpc_decoder_0
  id: wimaxldpc_ldpc_decoder
  parameters:
    max_iterations: '10'
    num_threads: '4'
    rate: '1'
    soft: 'True'
    z: z_factor
  states: {}
- name: wimaxldpc_ldpc_encoder_0
  id: wimaxldpc_ldpc_encoder
  parameters:
    num_threads: '1'
    rate: '1'
    z: z_factor
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', mapper_preamble_insert_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', mapper_prbs_sink_b_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, wimaxldpc_ldpc_encoder_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, wimaxldpc_ldpc_decoder_0, in]
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [channels_channel_model_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', mapper_preamble_sync_demapper_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [mapper_mapper_0, '0', root_raised_cosine_filter_0, '0']
- [mapper_prbs_source_b_0, '0', blocks_throttle_0, '0']
- [mapper_preamble_insert_bb_0, '0', mapper_mapper_0, '0']
- [mapper_preamble_sync_demapper_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [mapper_preamble_sync_demapper_0, '0', qtgui_time_raster_sink_x_0_1, '0']
- [root_raised_cosine_filter_0, '0', channels_channel_model_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_costas_loop_cc_0, '0']
- [wimaxldpc_ldpc_decoder_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [wimaxldpc_ldpc_encoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
