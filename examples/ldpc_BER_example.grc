<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value>SNR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_ldpc_block_len</value></param>
<param><key>value</key><value>2304</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cfo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Freq Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1e-1</value></param>
<param><key>step</key><value>1e-3</value></param>
<param><key>stop</key><value>1e-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>(z_factor / 96.0) * base_ldpc_block_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataword_len</value></param>
<param><key>value</key><value>codeword_len * rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pream</value></param>
<param><key>value</key><value>(mapper.preamble_generator(preamble_len,511,1033)).get_preamble()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2.0/3.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3200000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sro</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Sample Rate Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1e-1</value></param>
<param><key>step</key><value>1e-3</value></param>
<param><key>stop</key><value>1e-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>z_factor</value></param>
<param><key>value</key><value>24</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Flip the incoming soft bits 
so they match what the 
ldpc decoder is expecting.</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_length</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>int(dataword_len)</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>int(codeword_len)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0+sro</value></param>
<param><key>freq_offset</key><value>cfo</value></param>
<param><key>noise_voltage</key><value>(10**(-SNR/10.0))*np.sqrt(samp_per_sym)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>[1]</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.000001</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>1e-8</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from cmath import exp, pi; from random import randint; import numpy as np;</value></param>
</block>
<block>
<key>mapper_mapper</key>
<param><key>id</key><value>mapper_mapper_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>mapper_prbs_sink_b</key>
<param><key>id</key><value>mapper_prbs_sink_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>int(dataword_len)</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>int(dataword_len)</value></param>
</block>
<block>
<key>mapper_preamble_insert_bb</key>
<param><key>id</key><value>mapper_preamble_insert_bb_0</value></param>
<param><key>preamble</key><value>pream</value></param>
<param><key>width</key><value>int(codeword_len) + preamble_len</value></param>
</block>
<block>
<key>mapper_preamble_sync_demapper</key>
<param><key>id</key><value>mapper_preamble_sync_demapper_0</value></param>
<param><key>acquire_bit_thresh</key><value>1</value></param>
<param><key>loose_bit_thresh</key><value>3</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>passthrough</key><value>False</value></param>
<param><key>preamble</key><value>pream</value></param>
<param><key>symbol_map</key><value>[0,1,3,2]</value></param>
<param><key>width</key><value>int(codeword_len) + preamble_len</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>840-84</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1</value></param>
<param><key>ncols</key><value>int(codeword_len) </value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>samp_per_sym</value></param>
<param><key>ntaps</key><value>11</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate/samp_per_sym</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>samp_per_sym*0+1</value></param>
<param><key>ntaps</key><value>11</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate/samp_per_sym</value></param>
</block>
<block>
<key>wimaxldpc_ldpc_decoder</key>
<param><key>id</key><value>wimaxldpc_ldpc_decoder_0</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>max_iterations</key><value>10</value></param>
<param><key>num_threads</key><value>4</value></param>
<param><key>soft</key><value>True</value></param>
<param><key>z</key><value>z_factor</value></param>
</block>
<block>
<key>wimaxldpc_ldpc_encoder</key>
<param><key>id</key><value>wimaxldpc_ldpc_encoder_0</value></param>
<param><key>rate</key><value>1</value></param>
<param><key>num_threads</key><value>1</value></param>
<param><key>z</key><value>z_factor</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>mapper_preamble_insert_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>mapper_prbs_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>wimaxldpc_ldpc_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_1</source_block_id><sink_block_id>wimaxldpc_ldpc_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>mapper_preamble_sync_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_mapper_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_insert_bb_0</source_block_id><sink_block_id>mapper_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_sync_demapper_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_preamble_sync_demapper_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wimaxldpc_ldpc_decoder_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wimaxldpc_ldpc_encoder_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
