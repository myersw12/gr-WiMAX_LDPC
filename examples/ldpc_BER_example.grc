options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: EbN0
  id: variable_qtgui_entry
  parameters:
    label: EbN0
    type: real
    value: '1.9'
  states: {}
- name: EbNo_linear
  id: variable
  parameters:
    value: 10.0**(EbN0/10.0)
  states: {}
- name: base_ldpc_block_len
  id: variable
  parameters:
    value: '2304'
  states: {}
- name: bits_per_sym
  id: variable
  parameters:
    comment: |-
      Make sure to change this
      if you change the modulation
      scheme.
    value: '1'
  states: {}
- name: codeword_len
  id: variable
  parameters:
    value: (z_factor / 96.0) * base_ldpc_block_len
  states: {}
- name: dataword_len
  id: variable
  parameters:
    value: codeword_len * rate
  states: {}
- name: rate
  id: variable
  parameters:
    value: 1.0/2.0
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: z_factor
  id: variable
  parameters:
    value: '96'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: (1/np.sqrt(EbNo_linear))  * np.sqrt(1.0/(rate*bits_per_sym))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pdu_length
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(dataword_len)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(codeword_len)
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from cmath import exp, pi; from random import randint; import numpy as np;
  states: {}
- name: mapper_demapper_soft_0
  id: mapper_demapper_soft
  parameters:
    modtype: mapper.BPSK
    symbol_values: '[0,1]'
  states: {}
- name: mapper_mapper_0
  id: mapper_mapper
  parameters:
    modtype: mapper.BPSK
    symbol_values: '[0,1]'
  states: {}
- name: mapper_prbs_sink_b_0
  id: mapper_prbs_sink_b
  parameters:
    reset_len: int(dataword_len)
    which_mode: '"PRBS31"'
  states: {}
- name: mapper_prbs_source_b_0
  id: mapper_prbs_source_b
  parameters:
    reset_len: int(dataword_len)
    which_mode: '"PRBS31"'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Constellation Plot
    size: int(codeword_len)
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    name: '"Soft Demod Bit Raster"'
    ncols: 'int(codeword_len) '
    nrows: '100'
    samp_rate: '1'
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    name: '"Post LDPC Bit Raster"'
    ncols: 'int(codeword_len) '
    nrows: '100'
    samp_rate: '1'
    type: byte
    zmin: '0'
  states: {}
- name: wimaxldpc_ldpc_decoder_0
  id: wimaxldpc_ldpc_decoder
  parameters:
    max_iterations: '10'
    num_threads: '4'
    rate: '0'
    soft: 'True'
    z: z_factor
  states: {}
- name: wimaxldpc_ldpc_encoder_0
  id: wimaxldpc_ldpc_encoder
  parameters:
    num_threads: '1'
    rate: '0'
    z: z_factor
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', mapper_demapper_soft_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', mapper_mapper_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', mapper_prbs_sink_b_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', qtgui_time_raster_sink_x_0_1_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, wimaxldpc_ldpc_encoder_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, wimaxldpc_ldpc_decoder_0, in]
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [mapper_demapper_soft_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [mapper_demapper_soft_0, '0', qtgui_time_raster_sink_x_0_1, '0']
- [mapper_mapper_0, '0', blocks_add_xx_0, '1']
- [mapper_prbs_source_b_0, '0', blocks_throttle_0, '0']
- [wimaxldpc_ldpc_decoder_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [wimaxldpc_ldpc_encoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
