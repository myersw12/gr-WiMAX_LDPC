<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>EbN0</value></param>
<param><key>value</key><value>1.5</value></param>
<param><key>label</key><value>EbN0</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EbNo_linear</value></param>
<param><key>value</key><value>10.0**(EbN0/10.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>base_ldpc_block_len</value></param>
<param><key>value</key><value>2304</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bits_per_sym</value></param>
<param><key>comment</key><value>Make sure to change this
if you change the modulation
scheme.</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>(z_factor / 96.0) * base_ldpc_block_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataword_len</value></param>
<param><key>value</key><value>codeword_len * rate</value></param>
</block>
<block>
<key>variable_ldpc_decoder_def</key>
<param><key>id</key><value>ldpc_dec</value></param>
<param><key>file</key><value>/home/user/Documents/open_ofdm/ldpc_lib/alist/wimax_2304_0_5.alist</value></param>
<param><key>max_iter</key><value>10</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>sigma</key><value>0.5</value></param>
</block>
<block>
<key>variable_ldpc_encoder_def</key>
<param><key>id</key><value>ldpc_enc</value></param>
<param><key>file</key><value>/home/user/Documents/open_ofdm/ldpc_lib/alist/wimax_2304_0_5.alist</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>1.0/2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>z_factor</value></param>
<param><key>value</key><value>96</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>(1/np.sqrt(EbNo_linear))  * np.sqrt(1.0/(rate*bits_per_sym))</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>pdu_length</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>int(dataword_len)</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>int(codeword_len)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>ldpc_dec</value></param>
<param><key>mtu</key><value>int(codeword_len)</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0</value></param>
<param><key>encoder</key><value>ldpc_enc</value></param>
<param><key>mtu</key><value>int(codeword_len)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from cmath import exp, pi; from random import randint; import numpy as np;</value></param>
</block>
<block>
<key>mapper_demapper_soft</key>
<param><key>id</key><value>mapper_demapper_soft_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>mapper_mapper</key>
<param><key>id</key><value>mapper_mapper_0</value></param>
<param><key>modtype</key><value>mapper.QPSK</value></param>
<param><key>symbol_values</key><value>[0,1,3,2]</value></param>
</block>
<block>
<key>mapper_prbs_sink_b</key>
<param><key>id</key><value>mapper_prbs_sink_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>int(dataword_len)</value></param>
</block>
<block>
<key>mapper_prbs_source_b</key>
<param><key>id</key><value>mapper_prbs_source_b_0</value></param>
<param><key>which_mode</key><value>"PRBS31"</value></param>
<param><key>reset_len</key><value>int(dataword_len)</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>name</key><value>Constellation Plot</value></param>
<param><key>size</key><value>int(codeword_len)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_0</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>color1</key><value>2</value></param>
<param><key>name</key><value>"Post LDPC Bit Raster"</value></param>
<param><key>ncols</key><value>int(codeword_len) </value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_1_1</value></param>
<param><key>color1</key><value>2</value></param>
<param><key>name</key><value>"Soft Demod Bit Raster"</value></param>
<param><key>ncols</key><value>int(codeword_len) </value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>mapper_demapper_soft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>mapper_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>mapper_prbs_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_1</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mapper_demapper_soft_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_demapper_soft_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mapper_mapper_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mapper_prbs_source_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
